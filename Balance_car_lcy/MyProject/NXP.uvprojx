# Keil uVision project NXP.uvprojx, settings and files
target NXP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN27PS MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.4
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NXP
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Device\CMSIS\KEIL_CORE;.\Device\MM32SPIN2xx_p_LIB\HAL_lib\inc;.\Device\MM32SPIN2xx_p_LIB\Include;..\MyProject
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group STARTUP
    ./Device/MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
    ./Device/MM32SPIN2xx_p_LIB/Source/KEIL_StartAsm/: startup_MM32SPIN2xx_p.s
  group USER
    ./: main.c KEY.c LED.c isr.c TaskHandler.c ICM.c LCD.c BUZ.c CAM.c MOTOR.c ENCODER.c PID.c
  group HAL Lib
    ./Device/MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group Peripherals
    ./: board.c TIM_BASE.c SPI.c UART.c myTIM.c DMA.c EXTI.c
  group Includes
    ./: TIM_BASE.h board.h KEY.h UART.h myTIM.h SPI.h LED.h LCD.h ICM.h TaskHandler.h isr.h main.h BUZ.h CAM.h DMA.h EXTI.h MOTOR.h ENCODER.h PID.h
